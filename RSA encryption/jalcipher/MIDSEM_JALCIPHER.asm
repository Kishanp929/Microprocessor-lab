ORG 0H
LJMP MAIN
ORG 100H
MAIN:
PRIMES_P EQU 19
Q EQU 13
E EQU 173	
MOV 70H , #0F7H
MOV 71H , #0D8H
ACALL FINDD

HERE:SJMP HERE
ORG 130H


MOV P1 , #07H
FINDD:
MOV R2 , #00H
JUMP99:

MOV R3 ,  #0ADH   //173
MOV R4 , #0D8H   //216
MOV R5 , #00H

INC R2
MOV A , R4
MOV B , R2
MUL AB
ADD A ,#01
JNC JUMP56
INC B
JUMP56:
PINKY:

JUMP1:
CLR C
INC R5
MOV R4 , A
SUBB A , R3
JZ JUMP6
JNC JUMP1

CLR C
MOV A , B
SUBB A , #01H
MOV B , A
MOV A , R4
JC JUMP4

MOV A , R4
SUBB A ,#0ADH
CLR C
MOV B , A
MOV A , #0FFH
SUBB A , B
ADD A, #01H

SJMP PINKY
JUMP4:
//MOV A , R4
//CLR C
//SUBB A , #0ADH
//JZ JUMP7
//MOV A , R4
 MOV A , #14
 SUBB A, R5
 JC JUMPUL
LJMP JUMP99
JUMP7:
JUMP6:
JUMPUL:
MOV 72H , R5
RET










END